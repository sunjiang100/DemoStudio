# Keil uVision project G11.uvproj, settings and files
target G11A (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: G11BDS +hex
  AfterMake: fromelf --bin ".\Obj\G11BDS.axf" --output ".\Obj\G11BDS.bin"
  AfterMake: find "Total R" .\Lst\G11BDS.map
  c flags: Optim=4
  c define: DEBUG
  c include: .;D:\Keil\ARM\INC;
  memory RVCT4: ROM 0x3000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: RTX_Conf_CM.c
    ./USB/: usb_config.c File_Config.c
  group CAN_BUS
    ./CAN/: TaskCAN.cpp CAN.cpp
  group Source
    ./: UserSys.cpp Main.cpp
    ./Common/: Algol.c
    ./KeyDisp/: KeyDisp.cpp
    ./Speed/: Speed.cpp DriverCard.cpp
    ./UART/: TaskUART0.cpp IAP.cpp
    ./Print/: Print.cpp
    ./PWM/: PWM.cpp
    ./Switch/: Switch.cpp
    ./Camera/: Camera.cpp
    ./Record/: RecordModel.cpp
    ./isp/: isp_iap.c
  group Documentation
    ./: Abstract.txt 版本说明.txt 测试参数.h 接收中心数据.h 参数设置.h
  group Driver
    ./UART/: UART0.cpp UART1.cpp UART2 .cpp UART3.cpp
    ./flash/: DFE_25xxx.cpp DFF_25xxx.cpp
    ./RTC/: RTC.cpp
    ./SPI/: SPI0.cpp SSP0.cpp
    ./ADC/: ADC.cpp
    ./Timer/: Timer2.cpp
    ./KeyDisp/: LED_E308.cpp
    ./IIC/: IIC0.cpp IC_Card4442.cpp
    ./Print/: ASCII_Code24Dot.cpp CN_Code24Dot.cpp
    ./Speed/: Pulse.cpp
  group USB
    ./USB/: fs_usbh_msc.c MSD_SD_File.c serial_for_usb.cpp usbh_ohci_lpc17xx.c
  group USB_SD_Library
    D:/Keil/ARM/RV31/LIB/: USB_CM3.lib FS_CM3.lib
  group Retarget
    ./USB/: Retarget.c
  group GPS
    ./GPS/: GPS.cpp GPS_Pack.cpp BD_Update.cpp
  group GSM_GPRS
    ./GSM_GPRS/: ATCmd.cpp BB_GPRS_Cmd.cpp TH_GPRS_Cmd.cpp GSM_GPRS.cpp GPRS_Cmd.cpp GPRS_Alig.cpp GSM_GPRS_Send.cpp
  group SMS
    ./SMS/: SMS.cpp
  group Accelerometer
    ./Accelerometer/: kionix_kxtf9_driver.c i2c_interface.c kionix_kxtf9_common.cpp
  group RXT
    ./RTX_CM/: HAL_CM3.c rt_Event.c rt_List.c rt_Semaphore.c rt_Robin.c rt_Mutex.c rt_MemBox.c rt_Mailbox.c rt_Timer.c rt_Time.c rt_Task.c rt_System.c SVC_Table.s
target DEBUG (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: G11_DEBUG +hex
  c flags: Optim=4
  c include: .\;D:\Keil\ARM\INC
  asm define: DEBUG
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Obj\G11.sct
